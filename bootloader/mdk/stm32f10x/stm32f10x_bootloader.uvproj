# Keil uVision project stm32f10x_bootloader.uvproj, settings and files
target stm32f10x_bootloader (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f10x_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3
  c define: __RTX, STM32F10X_MD,TARGET_STM32F10X, CPU_STM32F10X_MD
  c misc: --diag_suppress=2532
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_ST\TARGET_STM32F10x;..\..\..\shared\rtos;..\..\..\shared\cmsis\TARGET_Freescale\include;..\..\..\shared\flash_algo\TARGET_Freescale
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\..\shared\cmsis\TARGET_ST\TARGET_STM32F10x\TOOLCHAIN_ARM_STD\STM32F10x.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_ST/TARGET_STM32F10x/: system_stm32f10x.c
    ../../../shared/cmsis/TARGET_ST/TARGET_STM32F10x/TOOLCHAIN_ARM_STD/: startup_stm32f10x_md.s
  group Common
    ../../Common/src/: flash_svc.c main.c RTX_Config.c SVC_Table.s usbd_user_msc.c version.c
    ../../hal/TARGET_Freescale/TARGET_MK20DX/: usb_config.c
  group HAL
    ../../hal/TARGET_ST/TARGET_STM32F10x/: flash_hal.c gpio.c read_uid.c usbd_STM32F103.c vector_table.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
