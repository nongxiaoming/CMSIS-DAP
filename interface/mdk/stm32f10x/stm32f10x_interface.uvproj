# Keil uVision project stm32f10x_interface.uvproj, settings and files
target stm32f10x_stm32f40x_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_kl25z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=1
  c define: TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_FRDM_KL25Z, INTERFACE_GEN_32KHZ
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL25Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_ST/TARGET_STM32F10x/: system_stm32f10x.c
    ../../../shared/cmsis/TARGET_ST/TARGET_STM32F10x/TOOLCHAIN_ARM_STD/: startup_stm32f10x_md.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c serial.c virtual_fs.c target_flash.c intelhex.c
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: usb_config.c
  group HAL-Interface
    ../../interface/hal/TARGET_ST/TARGET_STM32F10X/: DAP_config.h gpio.c read_uid.c uart.c usb_buf.h
  group HAL-Target
    ../../target/hal/DBG_ST/DBG_STM32F407/: arch_max_app_config.c target_reset.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target stm32f10x_stm32f40x_mbed_bootloader_if (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f10x_stm32f40x_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_20K, TARGET_STM32F10X, __RTX, DBG_KL25Z, STM32F10X_MD,CPU_STM32F10X_MD
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_ST\DBG_STM32F407;..\..\interface\hal\TARGET_ST\TARGET_STM32F10X;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_ST\TARGET_STM32F10x;..\..\..\shared\rtos
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\..\shared\cmsis\TARGET_ST\TARGET_STM32F10x\TOOLCHAIN_ARM_STD\STM32F10x_mbed_bootloader.sct
